# IAR project GFX02Z1_FlashLoader.ewp, settings and files
configuration GFX02Z1_FlashLoader (ARM, debug)
  General.OGChipSelectEditMenu: STM32H742ZI ST STM32H742ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: EXT_BOARD_GFX02Z1; USE_HAL_DRIVER; STM32H742xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../../../../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../../../../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GFX02Z1_FlashLoader.hex
  ILINK.IlinkOutputFile: FlashLoader.out
  ILINK.IlinkIcfFile: stm32_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GFX02Z1_FlashLoader_Tests (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H723ZG ST STM32H723ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCDefines: EXTERNAL_LOADER_TEST; EXT_BOARD_GFX02Z1; USE_HAL_DRIVER; STM32H723xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../DISPLAY/Target; ../../../../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../../../../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/mx25l6433f; ../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: GFX02Z1_FlashLoader.out
  ILINK.IlinkIcfFile: stm32h723xx_flash.icf
  group Application/EWARM
    ./: startup_stm32h723xx.s
  group Application/Loader
    ../Core/Src/: Dev_Inf.c Loader_Src.c
    ./: stm32_flash.icf
  group Application/User/Core
    ../Core/Src/: main.c stm32_eval_spi_flash.c stm32h7xx_.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
